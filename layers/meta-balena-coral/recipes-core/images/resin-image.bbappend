include resin-image.inc

IMAGE_INSTALL_append = " \
    imx-board-wlan \
    kernel-module-imx-gpu-viv \
"
